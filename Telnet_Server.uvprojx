# Keil uVision project Telnet_Server.uvprojx, settings and files
target STM32F107 Flash (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Telnet_Server
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: Telnet_Server.c Telnet_Server_UIF.c rtc.c rtc.h Backlight.c Backlight.h Timer.c Timer.h sntp.c sntp.h
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:A/D Converter 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Network:CORE 7.0.0, Network:Interface:ETH 7.0.0, Network:Service:Telnet Server 7.0.0, Network:Socket:TCP 7.0.0, Network:Socket:UDP 7.0.0, CMSIS Driver:Ethernet MAC 2.1, CMSIS Driver:Ethernet PHY:DP83848C 6.1, CMSIS Driver:SPI 2.2, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0
